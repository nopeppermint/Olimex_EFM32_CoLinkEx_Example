# Keil uVision project Blinky.uvproj, settings and files
target EFM32G210F128 CoLinkEx (ARM-ADS)
  device: EFM32G210F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: EFM32G210F128 DEBUG_EFM
  c include: ..\bsp;..\..\..\..\RV31\LIB\EnergyMicro\emlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./: startup_efm32g.s system_efm32g.c
  group EMLib
    ../../emlib/src/: em_gpio.c em_rmu.c em_system.c em_cmu.c em_assert.c em_emu.c
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target EFM32G210F128 Ulink2 (ARM-ADS)
  device: EFM32G210F128 Energy Micro
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: EFM32G210F128 DEBUG_EFM
  c include: ..\bsp;..\..\..\..\RV31\LIB\EnergyMicro\emlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
