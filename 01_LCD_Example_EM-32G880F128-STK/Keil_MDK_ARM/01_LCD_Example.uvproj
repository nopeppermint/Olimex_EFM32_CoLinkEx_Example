# Keil uVision project 01_LCD_Example.uvproj, settings and files
target CoLinkEx (ARM-ADS)
  device: EFM32G880F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: 01_LCD_Example
  c flags: Optim=1
  c define: EFM32G880F128  DEBUG_EFM
  c misc: --c99
  c include: ..\..\CMSIS;..\..\drivers;..\..\01_LCD_Example_EFM32G880F128-STK;..\..\EFM32G\Include;..\..\emlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../EFM32G/Source/: system_efm32g.c
    ../../EFM32G/Source/ARM/: startup_efm32g.s
  group emlib
    ../../emlib/src/: em_assert.c em_gpio.c em_system.c em_cmu.c em_emu.c em_lcd.c em_rtc.c
  group User
    ../: emlcd.c lcdtest.c
  group Driver
    ../../drivers/: rtcdrv.c segmentlcd.c
target J-Link (ARM-ADS)
  device: EFM32G880F128 Energy Micro
  cpu: as above
  output: 01_LCD_Example
  c flags: Optim=1
  c define: EFM32G880F128  DEBUG_EFM
  c misc: --c99
  c include: ..\..\CMSIS;..\..\01_LCD_Example_EFM32G880F128-STK;..\..\drivers;..\..\EFM32G\Include;..\..\emlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
